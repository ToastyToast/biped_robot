Commit message: Add locale note to biped_description README.md

File: biped_description/urdf/biped.urdf (robot description, URDF)
Before this commit: robot biped, 1 links, 0 joints
Links:
- link base_link: geometry visual cylinder length=0.6 radius=0.2
